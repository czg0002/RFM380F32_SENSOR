# Keil uVision project RFM380F32_GACL24A.uvprojx, settings and files
target RFM380F32_GACL24A_Release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: RFM380F32_GACL24A +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc;C:\Users\Administrator\AppData\Local\Arm\Packs\ARM\CMSIS\5.8.0\CMSIS\Core\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group common
    ./: startup_cmt2380f32.s
    ../../../../mcu/common/: system_cmt2380f32.c
  group source
    ../source/: main.c Base.c CMT2300Config.c KeyScan.c cmt2300a_params.c cmt2300a_hal.c cmt2300a.c
  group driver
    ../../../../driver/src/: ddl.c interrupts_cmt2380f32.c clk.c gpio.c adc.c bt.c uart.c
    ../source/: interrupt.c
software components: CMSIS:CORE 5.5.0
